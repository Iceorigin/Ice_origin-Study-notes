# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\APP;.\Malloc;.\Fatfs;.\Module\IIC;.\Module\AT24Cxx;.\Module\Key;.\Module\Led;.\Module\Tftlcd;.\Module\Touch;.\Module\MPU6050;.\Module\MPU6050\eMPL;.\Module\SRAM;.\Module\SD_Card;.\Module\Flash;.\Module\SPI;.\Module\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group Public
    ./Public/: System.c System.h SysTick.c SysTick.h Usart.c Usart.h
  group Module
    ./Module/Tftlcd/: tftlcd.c
    ./Module/Touch/: touch.c
    ./Module/Led/: led.c
    ./Module/Key/: key.c
    ./Module/IIC/: iic.c
    ./Module/AT24Cxx/: at24cxx.c
    ./Module/MPU6050/: mpu6050.c
    ./Module/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Module/SRAM/: sram.c
    ./Module/Flash/: flash.c
    ./Module/SPI/: spi.c
    ./Module/RTC/: rtc.c
  group Malloc
    ./Malloc/: malloc.c
  group SD_Card
    ./Module/SD_Card/: sd_sdio.c sd_sdio.h
  group Fatfs
    ./Fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
